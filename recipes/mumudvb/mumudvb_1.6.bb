require mumudvb.inc

SRC_URI += "file://autoconf_downgrade.patch;patch=1"
