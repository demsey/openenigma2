require linux-opendreambox.inc

SRCREV = "66ff384c9081e132bd9472c41b7815a9cdd8841a"
PR = "r0"

