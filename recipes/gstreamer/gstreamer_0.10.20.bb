require gstreamer.inc

PR = "r0"

SRC_URI += "file://po-makefile-fix.patch;patch=1"

