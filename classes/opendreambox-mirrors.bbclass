MIRRORS_append () {
ftp://.*/.*	http://dreamboxupdate.com/sources-mirror/
https?$://.*/.*	http://dreamboxupdate.com/sources-mirror/
}
