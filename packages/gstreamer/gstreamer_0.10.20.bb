require gstreamer.inc

FILE_PR = "r0"

SRC_URI += "file://po-makefile-fix.patch;patch=1"

