require flac.inc
PR = "r0"

do_stage () {
	autotools_stage_all
}
